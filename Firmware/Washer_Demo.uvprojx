# Keil uVision project Washer_Demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: WashingMachine +hex
  AfterMake: cmd.exe /c copy /Y ".\Objects\WashingMachine.hex" "..\WashingMachine.hex"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no_unaligned_access
  c include: .\Start;.\Library;.\User;.\Application;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group FreeRTOS
    ./FreeRTOS/: tasks.c queue.c list.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/include/: FreeRTOS.h FreeRTOSConfig.h task.h queue.h semphr.h list.h portable.h projdefs.h mpu_wrappers.h StackMacros.h croutine.h
  group Application
    ./Application/: app_tasks.c app_tasks.h app_config.h bsp.c bsp.h flash_log.c flash_log.h lcd1602.c lcd1602.h oled_font.h washer_control.c washer_control.h washer_plant.c washer_plant.h washer_types.c washer_types.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
